# Keil uVision project Coded_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Coded_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Device\KEY;..\Device\Nixie_tube;..\HARDWARE\IIC;..\HARDWARE\Timer;..\SYSTEM\delay;..\Project
  group User
    ./: STARTUP.A51 main.c
  group System
    ../SYSTEM/delay/: Delay.c
  group HARDWARE
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/IIC/: IIC.c
  group Device
    ../Device/KEY/: keyboard.c
    ../Device/Nixie_tube/: Nixie_tube.c
